SRC_URI += "git://git@github.ibm.com/openbmc/phosphor-networkd;nobranch=1;protocol=ssh"
SRCREV = "e6b69ccd2eb750641de6abbbafd607f559559db0"
