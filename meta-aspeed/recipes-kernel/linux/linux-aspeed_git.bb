KBRANCH ?= "1020-dev-5.8"
LINUX_VERSION ?= "5.8.17"

SRCREV="8d946854880002c82acd53965b7bd1dfcadeb9f9"

require linux-aspeed.inc
